## configs/smdk2440_defconfig
```kconfig
CONFIG_ARM=y
CONFIG_TARGET_SMDK2440=y
# CONFIG_CMD_SETEXPR is not set
CONFIG_SYS_PROMPT="SMDK2440 # "
```
